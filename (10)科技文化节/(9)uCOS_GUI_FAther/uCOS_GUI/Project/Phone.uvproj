# Keil uVision project Phone.uvproj, settings and files
target uCOS_GUI (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Phone +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\Source\Startup;..\Source\FWLib\inc;..\Source\uCGUI\inc;..\Source\uCGUI\LCDDriver;..\Source\uCGUI\Config;..\Source\BSP;..\Source\APP;..\Source\UCOSII\CONFIG;..\Source\UCOSII\CORE;..\Source\UCOSII\PORT;..\Source\ITFace
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Source/Startup/: system_stm32f10x.c core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.h
    ../Source/Startup/startup/: startup_stm32f10x_hd.s
  group FWLib
    ../Source/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOSII-CORE
    ../Source/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../Source/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../Source/UCOSII/CONFIG/: includes.h os_cfg.h
  group uCOS-Ⅱ/GUI_X
    ../Source/uCGUI/: GUI_X_Touch.c GUI_X_uCOS.c
  group uCGUI/Lib
    ../Source/uCGUI/: uCGUI.lib
  group uCGUI/LCDDriver
    ../Source/uCGUI/LCDDriver/: ili9320.c ili9320_api.c ili9320_ucgui.c
  group uCGUI/Config
    ../Source/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group GUI_Font
    ../Source/uCGUI/GUI_Font/: HZK16.c
  group BITmap
    ../Source/ITFace/Bitmap/: backface.c idea.c GSMback.c masterback.c
  group BSP
    ../Source/BSP/: bsp.c
  group APP
    ../Source/APP/: App.c stm32f10x_it.c
  group ITFace
    ../Source/ITFace/: Face.c change.c news.c Events.c GUIDEMO.c GSMface.c master.c news2.c
  group GSM
    ../Source/GSM/: GSM.c
  group Condition_value
    ../Source/Condition_value/: humiture.c
  group NRF24L01
    ../Source/NRF24L01/: 24g.c spi.c Dealdata.c
  group WIFI
    ../Source/WIFI/: WIFI.c
