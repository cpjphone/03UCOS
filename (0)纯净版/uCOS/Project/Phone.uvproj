# Keil uVision project Phone.uvproj, settings and files
target uCOS_GUI (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Phone +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\Source\Startup;..\Source\FWLib\inc;..\Source\uCGUI\inc;..\Source\uCGUI\LCDDriver;..\Source\uCGUI\Config;..\Source\BSP;..\Source\APP;..\Source\UCOSII\CONFIG;..\Source\UCOSII\CORE;..\Source\UCOSII\PORT;..\Source\ITFace
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Startup
    ../Source/Startup/startup/: startup_stm32f0xx_ld.s
    ../Source/Startup/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
  group FWLib
    ../Source/FWLib/src/: stm32f0xx_gpio.c stm32f0xx_flash.c stm32f0xx_rcc.c stm32f0xx_misc.c
  group UCOSII-CORE
    ../Source/UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../Source/UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOSII-CONFIG
    ../Source/UCOSII/CONFIG/: includes.h os_cfg.h
  group BSP
    ../Source/BSP/: bsp.c
  group APP
    ../Source/APP/: App.c
  group Condition_value
    ../Source/Condition_value/: humiture.c
